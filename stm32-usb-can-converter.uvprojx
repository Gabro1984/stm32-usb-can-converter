# Keil uVision project stm32-usb-can-converter.uvprojx, settings and files
target usb-can-converter (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-usb-can-converter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F105xC,USE_HAL_DRIVER,USE_STM3210C_EVAL
  c include: .\app\include;.\lib\include\common;.\lib\include\device;.\lib\include\hal;.\lib\include\hal\Legacy;.\usb\class\include;.\usb\core\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./app/src/: bsp.c can_conf.c main.c stm32f1xx_it.c system_stm32f1xx.c usbd_conf.c usbd_customhid_if.c usbd_desc.c
  group lib
    ./lib/src/: stm32f1xx_hal.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c
  group usb
    ./usb/class/src/: usbd_customhid.c
    ./usb/core/src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group cmsis
    ./lib/src/cmsis/arm/: startup_stm32f105xc.s
